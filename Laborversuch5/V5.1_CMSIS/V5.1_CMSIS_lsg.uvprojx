# Keil uVision project V5.1_CMSIS_lsg.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MCTPraktikum
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: DAC.c main.c Stepper.c I2C.c LCD.c LCDInit.c Temperatur.c TIM3_PWM.c USART2.c ESP_USART3.c
software components: CMSIS:CORE 5.4.0, Device:STM32Cube LL:Common 1.2.7, Device:STM32Cube LL:DAC 1.2.7, Device:STM32Cube LL:GPIO 1.2.7, Device:STM32Cube LL:I2C 1.2.7, Device:STM32Cube LL:PWR 1.2.7, Device:STM32Cube LL:RCC 1.2.7, Device:STM32Cube LL:TIM 1.2.7, Device:STM32Cube LL:USART 1.2.7, Device:STM32Cube LL:UTILS 1.2.7, Device:Startup 2.6.3
